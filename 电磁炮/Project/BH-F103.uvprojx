# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\HARDWARE\OLED;..\HARDWARE\oledSPI;..\HARDWARE\delay;..\HARDWARE\User_Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: stm32f10x_it.c main.c
    ../User/USART/: bsp_usart.c
    ../User/BUFFER/: buffer.c
    ../User/OPENMV/: openmv.c
    ../User/TIMER/: bsp_timer.c
    ../User/CONTROL/: control.c
    ../User/KEY/: bsp_key.c
    ../User/LED/: bsp_led.c
    ../User/RedRay/: RedRay.c
  group DOC
    ../Doc/: readme.txt
  group HAEDWRE
    ../HARDWARE/OLED/: exti.c key.c menuitem.c oled.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/User_Control/: user_control.c
    ../HARDWARE/oledSPI/: spi.c
